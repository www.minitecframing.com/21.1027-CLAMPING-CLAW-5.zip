# Autodesk Inventor assembly: 21.1027 CLAMPING CLAW
## iProperties
Created: 2007-01
Part Number: 21.1027 CLAMPING CLAW
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
